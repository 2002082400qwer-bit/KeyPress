# Keil uVision project TXD01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: TXD01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\usb;..\lib;..\app
  group app
    ../app/: app_ws2812.c App_keypress.c app.h
  group User
    ../user/: main.c task.c task.h
  group lib
    ../lib/: GPIO.c NVIC.c GPIO_Isr.c Timer_Isr.c Timer.c Delay.c UART.c UART_Isr.c SPI.c SPI_Isr.c
    ../../键盘项目/lib/: Switch.h
  group usb
    ../usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c usb_config.h usb_timer.c usb_timer.h KEYPRESS.c ws2812.c
